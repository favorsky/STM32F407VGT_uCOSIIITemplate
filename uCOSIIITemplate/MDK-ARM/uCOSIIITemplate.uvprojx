# Keil uVision project uCOSIIITemplate.uvprojx, settings and files
target uCOSIIITemplate (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uCOSIIITemplate
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ..\Src\uC-CPU; ..\Src\uC-CPU\ARM-Cortex-M4\RealView; ..\Src\uC-LIB\Ports\ARM-Cortex-M4\RealView; ..\Src\uC-LIB; ..\Src\uCOS-III\Source; ..\Src\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView; ..\Src; ..\Src\BSP; ..\Src\BSP\OS\uCOS-III; ..\Src\APPs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c gpio.c usart.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_cfg.h os_app_hooks.h os_cfg_app.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/BSP
    ../Src/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c cpu_bsp.c bsp_button.c
    ../Src/BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
    ../Src/: startup.s
    ./: bsp_uart.c
  group OS/uCOSIII
    ../Src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group OS/uCOSIII-Lib
    ../Src/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../Src/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group OS/uCOSIII-CPU
    ../Src/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../Src/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group OS/uCOSIII-Ports
    ../Src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
software components: CMSIS:CORE 4.1.0
